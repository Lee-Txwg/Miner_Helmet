# Keil uVision project xiaobaiSTM32.uvprojx, settings and files
target xiaobaiSTM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xiaobaiSTM32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\BH1750;..\HARDWARE\DHT11;..\HARDWARE\OLED;..\SYSTEM\TIMER;..\HARDWARE\KEY;..\SYSTEM\EXTI;..\NET\device;..\NET\MQTT;..\NET\onenet;..\NET\cJSON;..\HARDWARE\MQ2;..\HARDWARE\GPS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MQ2/: mq2.c
    ../HARDWARE/GPS/: gps.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/EXTI/: exti.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c
  group NET
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
    ../NET/cJSON/: cJSON.c
